Commit message: fixing problems of gazebo_palletizer

File: src/palletizer_gazebo_simulation/demo_world/urdf/red_cube.urdf (robot description, URDF)
Before this commit: robot red_cube, 1 links, 0 joints
Links:
- link base_link: mass 0.1 -> 0.3
